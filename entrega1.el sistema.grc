options:
  parameters:
    author: Homero Ortega Boada
    generate_options: qt_gui
    id: antennas_array_gnuradio_demo
    output_language: python
    title: antennas_array_gnuradio_demo
  states: {}

blocks:
- name: Dz
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: N
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Resol_angular_gr
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: Rmax
  id: variable
  parameters:
    value: '6'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: phi_i_gr
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: phi_i_gr
    start: '0'
    step: Resol_angular_gr
    stop: '36000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: theta_i_gr
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: theta_i_gr
    start: '0'
    step: Resol_angular_gr
    stop: '36000'
    value: '0'
  states: {}
- name: w
  id: variable
  parameters:
    value: '[1,1,1,1]'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {}
- name: b_antennaarraylinearz_0
  id: b_antennaarraylinearz
  parameters:
    Dz: Dz
    phi_i_gr: '0'
    theta_i_gr: theta_i_gr
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: w[0]
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: w[1]
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: w[1]
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: w[1]
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: int
    out_type: complex
    symbol_table: (-1.-1.j, -1.+1.j, 1.+1.j, 1.-1.j)
  states: {}
- name: epy_block_0_1_0_0
  id: epy_block
  parameters:
    Rmax: Rmax
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import matplotlib.pyplot as plt

      class polar_graf_f(gr.sync_block):
          """
          Grafica polar, pero los valores a graficar estan dados por la senal de magnitud entrante y el parametro angular theta. Hecho por Homero Ortega Boada. Universidad Industrial de Santander.
      Permite observar en el espacio el punto de observacion de un usuario receptor mientras ser mueve de manera angular con respecto a la posición del arreglo. Permite graficar el patron de radiación si se variar la posición de observación para todos los posiblea angulos.Rmax sirve para definir los limites de la grafica"""
          def __init__(self,samp_rate=32000, theta=0, Rmax=8, nombrex='Plano xy', nombrey='Eje z'):
              gr.sync_block.__init__(self,
                  name="e_polar_graf_f",
                  in_sig=[np.float32],
                  out_sig=None)

              #########################################
              ##        Parametros                   ##
              #########################################
              self.Tsamp=1./samp_rate
              self.theta=theta
              self.Rmax=Rmax
              self.nombrex=nombrex
              self.nombrey=nombrey
              self.contador=0
              self.fig=0
              self.ax=0

          ################################################
          ##       work() es la función clave           ##
          ## para capturar la senal entrante y graficar ##
          ################################################
          def work(self, input_items, output_items):
              R=input_items[0]
              z=R*np.cos(self.theta)
              y=R*np.sin(self.theta)
              if self.contador == 0:
                 self.contador=1
                 self.fig=plt.figure()
                 self.ax=self.fig.add_subplot(111)
                 self.ax.set_xlim(-self.Rmax,self.Rmax)
                 self.ax.set_ylim(-self.Rmax,self.Rmax)
                 plt.ylabel(self.nombrey)
                 plt.xlabel(self.nombrex)
              self.ax.plot(y,z, color="blue")
              plt.pause(self.Tsamp)
              return len(input_items[0])
    nombrex: '''Plano xy'''
    nombrey: '''Eje z'''
    samp_rate: samp_rate
    theta: theta_i_gr*np.pi/180
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: '[1]*Sps'
    type: ccc
  states: {}
- name: menu
  id: qtgui_tab_widget
  parameters:
    label0: constelacion y campo
    label1: tiempo y frec
    num_tabs: '2'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: menu@0:2,0,1,1
    name: '"Constelacion"'
    size: '1024'
    type: complex
    xmax: '10'
    xmin: '-10'
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: menu@1:2,0,1,1
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: menu@0:1,0,1,1
    label1: Campo E
    max: '10'
    min: '0'
    name: '"Campo E"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: menu@1:1,0,1,1
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: out2
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: out1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: out2
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: out1
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [b_antennaarraylinearz_0, '0', blocks_add_xx_0, '0']
- [b_antennaarraylinearz_0, '0', virtual_sink_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_complex_to_mag_0, '0', epy_block_0_1_0_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', b_antennaarraylinearz_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', b_antennaarraylinearz_0, '1']
- [blocks_multiply_const_vxx_1_0_0, '0', b_antennaarraylinearz_0, '2']
- [blocks_multiply_const_vxx_1_0_0_0, '0', b_antennaarraylinearz_0, '3']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_1_0_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_1_0_0_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_0, '0']
- [virtual_source_0_0, '0', qtgui_const_sink_x_1, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
