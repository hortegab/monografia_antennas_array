options:
  parameters:
    author: radiogis_director
    generate_options: qt_gui
    id: prueba_borrar
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (0, 10, 20)
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    N: '4'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Calculo los pesos complejos que afectan a la onda debido a la ubicacion del elemento radiador en el espacio"""

          def __init__(self,N=4,distancias=0):
              """fase_weight"""
              gr.sync_block.__init__(
                  self,
                  name='fase_weight',   
                  in_sig=[np.float32],
                  out_sig=[np.complex64,np.complex64,np.complex64,np.complex64]
              )
              self.distancias = distancias
              self.N=N

          def work(self, input_items, output_items):
              theta_i_gr=input_items[0]
              fases=-2*np.pi*self.distancias*np.cos(theta_i_gr*np.pi/180)
              output_items[:] = np.exp(fases*1j)
              return len(output_items[0])
    distancias: 1,2,3,4
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color3: '"red"'
    color4: '"red"'
    nconnections: '4'
    size: '1024'
    type: complex
  states: {}

connections:
- [blocks_vector_source_x_0, '0', epy_block_0, '0']
- [epy_block_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0, '1', qtgui_const_sink_x_0, '1']
- [epy_block_0, '2', qtgui_const_sink_x_0, '2']
- [epy_block_0, '3', qtgui_const_sink_x_0, '3']

metadata:
  file_format: 1
