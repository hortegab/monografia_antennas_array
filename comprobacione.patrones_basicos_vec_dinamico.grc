options:
  parameters:
    generate_options: qt_gui
    id: arraygeneral
    output_language: python
    title: arraygeneral
  states: {}

blocks:
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: amplificar
    start: '1'
    step: '1'
    stop: '20'
    value: '1'
  states: {}
- name: L_path
  id: variable
  parameters:
    value: po.L_path
  states: {}
- name: L_phi
  id: variable
  parameters:
    value: len(po.phi)
  states: {}
- name: L_theta
  id: variable
  parameters:
    value: len(po.theta)
  states: {}
- name: N
  id: variable
  parameters:
    value: len(posiciones)
  states: {}
- name: Rmax
  id: variable
  parameters:
    value: N
  states: {}
- name: excitaciones
  id: variable
  parameters:
    value: w_magnitudes*np.exp(1j*w_fases)
  states: {}
- name: patron
  id: variable
  parameters:
    value: np.array([1]*po.L_path)
  states: {state: disabled}
- name: patron
  id: variable
  parameters:
    value: antenna_tools.patron1()(po.phi_path(), po.theta_path())
  states: {state: disabled}
- name: patron
  id: variable
  parameters:
    value: antenna_tools.patronDipoloMediaOnda()(po.phi_path(), po.theta_path())
  states: {state: disabled}
- name: patron
  id: variable
  parameters:
    value: antenna_tools.patronDipoloCorto()(po.phi_path(), po.theta_path())
  states: {state: disabled}
- name: patron
  id: variable
  parameters:
    value: antenna_tools.patronMonopoloCuartoOnda()(po.phi_path(), po.theta_path())
  states: {state: disabled}
- name: patron
  id: variable
  parameters:
    value: antenna_tools.parche_sat()(po.phi_path(), po.theta_path())
  states: {}
- name: phi_apuntar_gr
  id: variable
  parameters:
    value: '0'
  states: {}
- name: po
  id: variable
  parameters:
    value: ruta3d.receiver_path(128)
  states: {}
- name: posiciones
  id: variable
  parameters:
    value: antenna_tools.posiciones_arreglo_planar(4,4,0.4)
  states: {state: disabled}
- name: posiciones
  id: variable
  parameters:
    value: antenna_tools.posiciones_arreglo_esferico(4,4,0.4)
  states: {state: disabled}
- name: posiciones
  id: variable
  parameters:
    value: antenna_tools.posiciones_arreglo_cilindro(4,4,0.4)
  states: {state: disabled}
- name: posiciones
  id: variable
  parameters:
    value: np.array([[0,0,0]])
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: theta_apuntar_gr
  id: variable
  parameters:
    value: '0'
  states: {}
- name: w_fases
  id: variable
  parameters:
    value: antenna_tools.calcularFasesApuntamiento(phi_apuntar_gr*np.pi/180,theta_apuntar_gr*np.pi/180, posiciones)
  states: {}
- name: w_magnitudes
  id: variable
  parameters:
    value: np.array([1]*N)
  states: {}
- name: antenna_tools
  id: epy_module
  parameters:
    source_code: "\t# Aqui se reunen una serie de funciones que puede ser de utilidad en la definicion o configuracion de arreglos de antenas\n\nimport numpy as np\nimport scipy.integrate as integrate\nimport scipy.interpolate as interp\n###############################################################################\n##     Funciones utiles para el direcionamiento del patron del arreglo       ##\n###############################################################################\n# Para apuntar el patron de un arreglo a una direccion phi,theta, es necesario conocer las fases\n# de con las que se debe alimentar a los radiadores. Para eso se usa la funcion calcularFasesApuntamiento()\n# de la siguiente manera:\n# * Llama esta funcion por ejemplo asi:w_apuntar=calcularFasesApuntamiento(phi,theta,posiciones)\n# * ve a tu arreglo y muliplica las exitaciones por w_apuntar\n# Nota: la version del profe Binomi se diferencia de esta en que entrega las exponenciales complejas\n# nos pareció más claro para ususario que se entregen las fases solamente.\ndef calcularFasesApuntamiento(phi,theta, posiciones):\n    normal = np.array((np.cos(phi)*np.sin(theta),np.sin(phi)*np.sin(theta),np.cos(theta)))\n    fases = -2*np.pi*posiciones@normal\n    return fases\n    \n###############################################################################\n##                 Funciones utiles para las aperturas                       ##\n###############################################################################\ndef amplitudCosElev(posiciones,escala=0.8):\n    centro = np.mean(posiciones,axis=0)\n    desplazamientos = posiciones-centro\n    radios = np.linalg.norm(desplazamientos,axis=1)\n    rmax=np.max(radios)\n    A = 1+np.cos(np.pi*escala*radios/rmax)\n    return A/np.linalg.norm(A)*A.size**.5\n    \n#distintos patrones de radiacion para elementos. Ver ejemplo de arreglo lineal abajo para su uso\n###############################################################################\n##     Patrones de radiacion que pueden ser usados en los radiadores         ##\n###############################################################################\n\ndef patron1():\n    # Patron arbitrario generado a partir de tabla\n    if (\"patron\" not in dir(patron1)):\n        angulosTheta = np.linspace(0,180,91)*np.pi/180\n        #angulosTheta = np.array([0,30,60,90,120,150,180])*np.pi/180\n        #intensidadesRel = np.array([1e-3,1,1.2,2,.3,.1,0])\n        #intensidadesRel = np.array([8,8.1,8,6.1,4.1,2.1,5])\n        intensidadesRel =np.array([3.9,4,4.1,4.2,4.3,4.2,4.25,4.2,4.1,4.05,4,3.95,3.95,\n            4,4.05,4.15,4.1,4.1,4.1,4.1,4.05,3.95,3.9,\n            3.85,3.8,3.8,3.9,3.95,4,4,4.05,4,4,4,3.9,3.85,\n            3.8,3.8,3.75,3.6,3.55,3.45,3.35,3.25,3.15,3.05,3,\n            2.85,2.7,2.65,2.6,2.6,2.6,2.6,2.6,2.6,2.5,2.5,2.45,\n            2.35,2.2,2.15,1.9,1.9,1.95,2,1.9,1,1,1.7,2.1,2.3,2.35,\n            2.25,2,1,1,1.8,2.1,2,1.8,1,2.1,2.5,2.55,2.5,2,1,0.5,2.2,2.45])\n        f_denorm = interp.interp1d(angulosTheta,intensidadesRel,kind=\"cubic\")\n        # potenciaMedia = integrate.dblquad(lambda fi,th: f_denorm(th)**2*np.sin(th),0,np.pi,-np.pi,np.pi)[0]/(4*np.pi)\n        # Por haber simetria respecto al eje z, la integral se reduce a\n        potenciaMedia = integrate.quad(lambda th: f_denorm(th)**2*np.sin(th),0,np.pi)[0]/2\n        escala = 1/potenciaMedia**.5 # para normalizar a potencia media 1\n        def patron(phi,theta):\n            return escala*f_denorm(theta)\n        patron1.patron = patron\n    return patron1.patron\n\ndef parche_sat():\n    # Patron de la antena parche para el satelite de proy\n    \n    # la tabla de valores que representa al patron desde 0 hasta 180 grados\n    angulosTheta = np.linspace(0,180,91)*np.pi/180\n    intensidadesRel =np.array([3.9,4,4.1,4.2,4.3,4.2,4.25,4.2,4.1,4.05,4,3.95,3.95,\n        4,4.05,4.15,4.1,4.1,4.1,4.1,4.05,3.95,3.9,\n        3.85,3.8,3.8,3.9,3.95,4,4,4.05,4,4,4,3.9,3.85,\n        3.8,3.8,3.75,3.6,3.55,3.45,3.35,3.25,3.15,3.05,3,\n        2.85,2.7,2.65,2.6,2.6,2.6,2.6,2.6,2.6,2.5,2.5,2.45,\n        2.35,2.2,2.15,1.9,1.9,1.95,2,1.9,1,1,1.7,2.1,2.3,2.35,\n        2.25,2,1,1,1.8,2.1,2,1.8,1,2.1,2.5,2.55,2.5,2,1,0.5,2.2,2.45])\n    \n    # La interpolacion\n    f_denorm = interp.interp1d(angulosTheta,intensidadesRel,kind=\"cubic\")\n    potenciaMedia = integrate.quad(lambda th: f_denorm(th)**2*np.sin(th),0,np.pi)[0]/2\n    escala = 1/potenciaMedia**.5 # para normalizar a potencia media 1\n    \n    # el patron para cualquier phi, theta\n    def patron(phi,theta):\n        return escala*f_denorm(theta)\n    parche_sat.patron = patron\n    return parche_sat.patron\n    \ndef patronDipoloCorto():\n    if (\"patron\" not in dir(patronDipoloCorto)):\n        f_denorm = np.sin\n        #simetria axial, eje z\n        potenciaMedia = integrate.quad(lambda th: f_denorm(th)**2*np.sin(th),0,np.pi)[0]/2\n        escala = 1/potenciaMedia**.5 # para normalizar a potencia media 1\n        def patron(phi,theta):\n            return escala*f_denorm(theta)\n        patronDipoloCorto.patron = patron\n    return patronDipoloCorto.patron\ndef patronDipoloMediaOnda():\n    self = patronDipoloCorto\n    if (\"patron\" not in dir(self)):\n        epsilon = 1e-6\n        def f_denorm(theta):\n            theta=np.array(theta)\n            determinado = (theta > epsilon) & ((np.pi-theta) > epsilon)\n            result = np.zeros(theta.shape)\n            theta_determinado = theta[determinado]\n            result[determinado] = np.cos(np.pi/2*np.cos(theta_determinado))/np.sin(theta_determinado) \n            return result\n        #simetria axial, eje z\n        potenciaMedia = integrate.quad(lambda th: f_denorm(th)**2*np.sin(th),0,np.pi)[0]/2\n        escala = 1/potenciaMedia**.5 # para normalizar a potencia media 1\n        def patron(phi,theta):\n            return escala*f_denorm(theta)\n        self.patron = patron\n    return self.patron\ndef patronMonopoloCuartoOnda():\n    self = patronMonopoloCuartoOnda\n    if (\"patron\" not in dir(self)):\n        epsilon = 1e-6\n        def f_denorm(theta):\n            theta=np.array(theta)\n            determinado = (theta > epsilon) & (theta <= np.pi/2)\n            result = np.zeros(theta.shape)\n            theta_determinado = theta[determinado]\n            result[determinado] = np.cos(np.pi/2*np.cos(theta_determinado))/np.sin(theta_determinado) \n            return result\n        #simetria axial, eje z\n        potenciaMedia = integrate.quad(lambda th: f_denorm(th)**2*np.sin(th),0,np.pi)[0]/2\n        escala = 1/potenciaMedia**.5 # para normalizar a potencia media 1\n        def patron(phi,theta):\n            return escala*f_denorm(theta)\n        self.patron = patron\n    return self.patron\n\n#def pmcoka(phi,theta):\n#    pmcoi=patronMonopoloCuartoOnda()\n#    p=pmcoi(phi,theta)\n#    return p\n##################################################################\n##   Varias configuraciones de posiciones para arreglos         ##\n##################################################################\n#     Arreglo planar\n# permite obtener las posiciones para un arreglo planar\n# organizado de manera que vemos Nx filas y Ny columnas\n# de manera que hay N=Nx x Ny radiadores y todos están distanciados\n# de sus vecinos en una distand D x lambda\n# las posiciones se entregan en forma de un vector de N elementos.\n\ndef posiciones_arreglo_planar(Nx,Ny, D):\n    return D*np.array([(x,y,0) for x in range(Nx) for y in range(Ny)])\n    \ndef posiciones_arreglo_esferico(Nx,Ny,D):\n    cx=(Nx-1)/2\n    cy=(Ny-1)/2\n    return D*np.array([(x,y,np.sqrt(2*max(cx,cy)**2-(x-cx)**2-(y-cy)**2)) for x in range(Nx) for y in range(Ny)])\n\ndef posiciones_arreglo_cilindro(Nx,Ny,D):\n    cx = (Nx-1)/2\n    return D*np.array([(x,y,np.sqrt(2*cx**2-(x-cx)**2)) for x in range(Nx) for y in range(Ny)])\n\ndef posiciones_arreglo_linealz(Nz,Dz):\n    return Dz*np.array([(0,0,z) for z in range(Nz)])\ndef posiciones_arreglo_sat_viejo():\n    # Todas las distancias estan en lambdas\n    # Bl el largo del panel solar\n    # Ba el ancho del panel solar\n    # D distancia entre radiadores de la parte basica\n    Bl=3\n    Ba=1\n    antena11=np.array([Ba/2, Bl,0])\n    antena12=np.array([-Ba/2, Bl,0])\n    antena13=np.array([Ba/2, Bl-Ba,0])\n    antena14=np.array([-Ba/2, Bl-Ba,0])\n    arreglo1=np.array([antena11,antena12,antena13,antena14])\n    return arreglo1    \n\n\ndef posiciones_arreglo_sat_ladoyp(Nx,Ny,D):\n    # radiadores en el eje y parte positiva\n    a1=posiciones_arreglo_planar(Nx,Ny,D)\n    # lo siguiente es para correr el array del centro para despejar el\n    # espacio que ocupa el cubo del satelite\n    a1=a1+np.array([-D/2,1.5*D,0])\n    return a1    \n\ndef posiciones_arreglo_sat_ladoydoble(Nx,Nypos,D):\n    # radiadores en el eje y a ambos lados\n    # Nypos, es el numero de elementos solo en el lado y positivo\n    a1=posiciones_arreglo_sat_ladoyp(Nx,Nypos,D)\n    a2=a1+np.array([0,-(Nypos+2)*D,0])\n    return np.concatenate((a1,a2))\n\ndef posiciones_arreglo_sat_ladoxp(Nx,Ny,D):\n    a1=posiciones_arreglo_planar(Nx,Ny,D)\n    # lo siguiente es para correr el array del centro para despejar el\n    # espacio que ocupa el cubo del satelite\n    a1=a1+np.array([1.5*D,-D/2,0])\n    return a1    \ndef posiciones_arreglo_sat_ladoxdoble(Nxpos,Ny,D):\n    # radiadores en el eje y a ambos lados\n    # Nypos, es el numero de elementos solo en el lado y positivo\n    a1=posiciones_arreglo_sat_ladoxp(Nxpos,Ny,D)\n    a2=a1+np.array([-(Nxpos+2)*D,0,0])\n    return np.concatenate((a1,a2)) \n\ndef posiciones_arreglo_sat_full(Nx,Ny,D):\n   a1=posiciones_arreglo_sat_ladoydoble(Nx,Ny,D)\n   a2=posiciones_arreglo_sat_ladoxdoble(Ny,Nx,D)\n   return np.concatenate((a1,a2)) \n   #return a1\n      \n\n"
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Ka
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: L_path
    type: float
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: patron
  states: {}
- name: epy_block_0_1_0_0_0
  id: epy_block
  parameters:
    L_path: L_path
    _source_code: |
      from mpl_toolkits import mplot3d
      import numpy as np
      from gnuradio import gr
      import matplotlib.pyplot as plt

      class polar_graf_f(gr.sync_block):
          """
      Hecho por Homero Ortega Boada. Universidad Industrial de Santander.
      Permite mostrar las graficas más relevantes para un arreglo de antenas como:
      * La distribución en 3d de los componentes del arreglo con su respectiva alimentación
      * Las alimentaciones que cada componente (radiador) tiene.
      * grafica polar del patron de arreglo con coordenadas esfericas. Las graficas las hacemos con herramientas externas a GNU Radio ya que al momento no sabiamos como hacerlo de otra manera. Los parametros de entrada son:

      * samp_rate: es la frecuencia de muestreo en Hz que nunca falta en GNURadio. Influye en la velocidad de la grafica, supuestamente se los valores de medicion del  campo llegan con esa rata
      * Rmax sirve para definir los limites de la grafica, se supone que es el máximo valor que puede llegar a tomar el campo en magnitud
      * phi: son los valores unicos usados en la grafica para phi. Usualmente phi es un vector de valores entre 0 y 2pi con un cierto paso angular
      theta: son los valores unicos usados en la grafica. Usualmente phi es un vector de valores entre 0 y pi con el mismo paso angular que phi. De manera que este vector tiene 2 veces menos valores que phi
      * posiciones: vector que contiene la posicion de cada uno de los componentes del arreglo
      * excitaciones: vector que contiene la alimentacion para cada uno de los componentes del arreglo
      * La senal que entra al bloque corresponde a las mediciones de campo realizadas  para todos los posibles ubicaciones angulares que se puede lograr con las combinaciones de phi y theta
      *L_path: es el numero de puntos que tiene la ruta. Es la longitud de la ruta

      Nota: Hemos pretendido que el patron se pueda redibujar en tiempo real para nuevas situaciones. Por ejemplo, que si en cierto momento cambia la alimentacion de los elementos de radiacion que entonces el patron se redibuje adotando la nueva forma. Pero tenemos un problema que nos frena y es la manera en que funcionan las graficas 3d de matplotlib. Toca buscar alternativas para lograrlo. 

      Retos para mejorar: es mas natural que el bloque pueda identifcar phi y theta a partir de las senals que aporta la ruta, es decir, usando las mismas senales que usa el bloque e_polar_graf_3d_p_f
      """
          def __init__(self,samp_rate=32000,phi=0,theta=0, posiciones=0, excitaciones=0, L_path=8192):
              gr.sync_block.__init__(self,
                  name="e_vector_antenna_graf_f",
                  in_sig=[(np.float32,L_path)],
                  out_sig=None)
                  
              # Parametros
              self.L_path=L_path                   
              self.Tsamp=1./samp_rate
              self.contador=0
              self.phi=phi
              self.theta=theta
              self.posiciones=posiciones
              self.excitaciones=excitaciones
              self.ax1=None
              self.ax2=None
                     
          # Canvas para graficar el patron solo
          def canvas_3d_patron(self,):
              fig=plt.figure()
              ax2=fig.add_subplot(1,1,1, projection='3d')
              ax2.set_xlabel('x')
              ax2.set_ylabel('y')
              ax2.set_zlabel('z')
              ax2.set_title("Patron de radiacion del arreglo")
              return ax2
              
          # Canvas para graficar el array con alimentacion y el patron
          def canvas_3d_alimentacion_y_patron(self, ):
              fig=plt.figure()
              ax1=fig.add_subplot(2,1,1, projection='3d')
              ax1.set_title("El Arreglo-sus elementos y alimentacion")
              ax1.set_xlabel('x')
              ax1.set_ylabel('y')
              ax1.set_zlabel('z')

              ax2=fig.add_subplot(2,1,2, projection='3d')
              ax2.set_xlabel('x')
              ax2.set_ylabel('y')
              ax2.set_zlabel('z')
              ax2.set_title("Patron de radiacion del arreglo")
              return ax1,ax2

          # Traduccion de coordenadas esfericas a cartecianas
          def esferica2cartesiana(self,phi,theta,R):
              x = R * np.cos(phi) * np.sin(theta)
              y = R * np.sin(phi) * np.sin(theta)
              z = R * np.cos(theta)
              return(x,y,z)                                   

          def graficaExcitaciones(self,ax=None):
              
              def sep_xyz(filas_xyz):
                  return (filas_xyz[:,0],filas_xyz[:,1],filas_xyz[:,2])
                      
              pmin=self.posiciones.min()
              pmax=self.posiciones.max()
              lims = (pmin-(pmax-pmin)*.1,pmax+(pmax-pmin)*.1)

              ax.plot3D(*sep_xyz(self.posiciones),'or')
              Emax=np.abs(self.excitaciones).max()
              if self.posiciones.shape[0]>1:
                  dmin=min((np.linalg.norm(x-y) for x in self.posiciones for y in self.posiciones if np.linalg.norm(x-y) >0))
                  factor = .618*dmin/Emax
              else:
                  factor = 1
                  lims = (-1,1)
              ax.quiver(*sep_xyz(self.posiciones),self.excitaciones.real*factor,self.excitaciones.imag*factor,np.zeros(self.excitaciones.shape))
              ax.set_xlim(*lims)
              ax.set_ylim(*lims)
              ax.set_zlim(*lims)
              
          def work(self, input_items, output_items):
              # Inicialmente se deben crear 3 matrices de NringsxNang:
              # * PHI
              # * THETA
              # * R
              # Nrings: es el numero de filasy equivale al numero de anillos en la graf 3d
              # Nang: es el numero de columnas y a la vez de puntos por cada anillo de la graf 3d
              R_path=input_items[0][0] 
              Nang=len(self.phi) 
              Nrings=len(self.theta)
              PHI,THETA=np.meshgrid(self.phi,self.theta)
              R=R_path.reshape(Nrings,Nang)
              Rmax=np.max(R)
              X,Y,Z=self.esferica2cartesiana(PHI,THETA,R)
                      
              # El if  es porque el canva solo se dibuna una vez y no hemos logrado que se haga
              # dentro del constructor.
              if self.contador == 0:
                  self.contador=1
                  # definimos el canvas por una unica vez
                  #self.ax2=self.canvas_3d_patron() # cuando queremos ver solo el patron
                  self.ax1,self.ax2=self.canvas_3d_alimentacion_y_patron()

              # Finalmente se ordena la grafica de los valores en X,Y,Z  
              #ax2.plot_wireframe(X,Y,Z)
              self.ax2.cla()
              self.ax1.cla()
              self.graficaExcitaciones(self.ax1)
              self.ax2.plot_surface(X,Y,Z,cmap="coolwarm")
              plt.pause(self.Tsamp)
                      
              return len(input_items[0])
    alias: 3d_f
    excitaciones: excitaciones
    phi: po.phi
    posiciones: posiciones
    samp_rate: samp_rate
    theta: po.theta
  states: {state: disabled}
- name: epy_block_0_1_0_0_0_0
  id: epy_block
  parameters:
    L_path: po.L_path
    _source_code: |
      from mpl_toolkits import mplot3d
      import numpy as np
      from gnuradio import gr
      import matplotlib.pyplot as plt

      class polar_graf_f(gr.sync_block):
          """
      Hecho por Homero Ortega Boada. Universidad Industrial de Santander.
      Permite mostrar las graficas más relevantes para un arreglo de antenas como:
      * La distribución en 3d de los componentes del arreglo con su respectiva alimentación
      * Las alimentaciones que cada componente (radiador) tiene.
      * grafica polar del patron de arreglo con coordenadas esfericas. Las graficas las hacemos con herramientas externas a GNU Radio ya que al momento no sabiamos como hacerlo de otra manera. Los parametros de entrada son:

      * samp_rate: es la frecuencia de muestreo en Hz que nunca falta en GNURadio. Influye en la velocidad de la grafica, supuestamente se los valores de medicion del  campo llegan con esa rata
      * Rmax sirve para definir los limites de la grafica, se supone que es el máximo valor que puede llegar a tomar el campo en magnitud
      * phi: son los valores unicos usados en la grafica para phi. Usualmente phi es un vector de valores entre 0 y 2pi con un cierto paso angular
      theta: son los valores unicos usados en la grafica. Usualmente phi es un vector de valores entre 0 y pi con el mismo paso angular que phi. De manera que este vector tiene 2 veces menos valores que phi
      * posiciones: vector que contiene la posicion de cada uno de los componentes del arreglo
      * excitaciones: vector que contiene la alimentacion para cada uno de los componentes del arreglo
      * La senal que entra al bloque corresponde a las mediciones de campo realizadas  para todos los posibles ubicaciones angulares que se puede lograr con las combinaciones de phi y theta
      *L_path: es el numero de puntos que tiene la ruta. Es la longitud de la ruta

      Nota: Hemos pretendido que el patron se pueda redibujar en tiempo real para nuevas situaciones. Por ejemplo, que si en cierto momento cambia la alimentacion de los elementos de radiacion que entonces el patron se redibuje adotando la nueva forma. Pero tenemos un problema que nos frena y es la manera en que funcionan las graficas 3d de matplotlib. Toca buscar alternativas para lograrlo. 

      Retos para mejorar: es mas natural que el bloque pueda identifcar phi y theta a partir de las senals que aporta la ruta, es decir, usando las mismas senales que usa el bloque e_polar_graf_3d_p_f
      """
          def __init__(self,samp_rate=32000,phi=0,theta=0, posiciones=0, excitaciones=0, L_path=8192):
              gr.sync_block.__init__(self,
                  name="e_vector_antenna_graf_f",
                  in_sig=[(np.float32,L_path)],
                  out_sig=None)
                  
              # Parametros
              self.L_path=L_path                   
              self.Tsamp=1./samp_rate
              self.contador=0
              self.phi=phi
              self.theta=theta
              self.posiciones=posiciones
              self.excitaciones=excitaciones
              self.ax1=None
              self.ax2=None
                     
          # Canvas para graficar el patron solo
          def canvas_3d_patron(self,):
              fig=plt.figure()
              ax2=fig.add_subplot(1,1,1, projection='3d')
              ax2.set_xlabel('x')
              ax2.set_ylabel('y')
              ax2.set_zlabel('z')
              ax2.set_title("Patron de radiacion del arreglo")
              return ax2
              
          # Canvas para graficar el array con alimentacion y el patron
          def canvas_3d_alimentacion_y_patron(self, ):
              fig=plt.figure()
              ax1=fig.add_subplot(1,2,1, projection='3d')
              ax1.set_title("El Arreglo-sus elementos y alimentacion")
              ax1.set_xlabel('x')
              ax1.set_ylabel('y')
              ax1.set_zlabel('z')

              ax2=fig.add_subplot(1,2,2, projection='3d')
              ax2.set_xlabel('x')
              ax2.set_ylabel('y')
              ax2.set_zlabel('z')
              ax2.set_title("Patron de radiacion del arreglo")
              return ax1,ax2

          # Traduccion de coordenadas esfericas a cartecianas
          def esferica2cartesiana(self,phi,theta,R):
              x = R * np.cos(phi) * np.sin(theta)
              y = R * np.sin(phi) * np.sin(theta)
              z = R * np.cos(theta)
              return(x,y,z)                                   

          def graficaExcitaciones(self,ax=None):
              
              def sep_xyz(filas_xyz):
                  return (filas_xyz[:,0],filas_xyz[:,1],filas_xyz[:,2])
                      
              pmin=self.posiciones.min()
              pmax=self.posiciones.max()
              lims = (pmin-(pmax-pmin)*.1,pmax+(pmax-pmin)*.1)

              ax.plot3D(*sep_xyz(self.posiciones),'or')
              Emax=np.abs(self.excitaciones).max()
              if self.posiciones.shape[0]>1:
                  dmin=min((np.linalg.norm(x-y) for x in self.posiciones for y in self.posiciones if np.linalg.norm(x-y) >0))
                  factor = .618*dmin/Emax
              else:
                  factor = 1
                  lims = (-1,1)
              ax.quiver(*sep_xyz(self.posiciones),self.excitaciones.real*factor,self.excitaciones.imag*factor,np.zeros(self.excitaciones.shape))
              ax.set_xlim(*lims)
              ax.set_ylim(*lims)
              ax.set_zlim(*lims)
              
          def work(self, input_items, output_items):
              # Inicialmente se deben crear 3 matrices de NringsxNang:
              # * PHI
              # * THETA
              # * R
              # Nrings: es el numero de filasy equivale al numero de anillos en la graf 3d
              # Nang: es el numero de columnas y a la vez de puntos por cada anillo de la graf 3d
              R_path=input_items[0][0] 
              M_patterns=len(input_items[0]) # numero de patrones recibidos
              Nang=len(self.phi) 
              Nrings=len(self.theta)
              PHI,THETA=np.meshgrid(self.phi,self.theta)
              R=R_path.reshape(Nrings,Nang)
              Rmax=np.max(R)
              X,Y,Z=self.esferica2cartesiana(PHI,THETA,R)
                      
              # El if  es porque el canva solo se dibuna una vez y no hemos logrado que se haga
              # dentro del constructor.
              if self.contador == 0:
                  self.contador=1
                  # definimos el canvas por una unica vez
                  #self.ax2=self.canvas_3d_patron() # cuando queremos ver solo el patron
                  self.ax1,self.ax2=self.canvas_3d_alimentacion_y_patron()

              # Finalmente se ordena la grafica de los valores en X,Y,Z  
              #ax2.plot_wireframe(X,Y,Z)

              self.ax1.cla()
              self.ax1.set_title("El Arreglo-sus elementos y alimentacion")
              self.ax1.set_xlabel('x')
              self.ax1.set_ylabel('y')
              self.ax1.set_zlabel('z')
              self.graficaExcitaciones(self.ax1)
              
              self.ax2.cla()        
              self.ax2.set_xlabel('x')
              self.ax2.set_ylabel('y')
              self.ax2.set_zlabel('z')
              self.ax2.set_title("Patron de radiacion del arreglo")

              self.ax2.plot_surface(X,Y,Z,cmap="coolwarm")
              plt.pause(self.Tsamp)
                      
              return len(input_items[0])
    alias: 3d_f
    excitaciones: excitaciones
    phi: po.phi
    posiciones: posiciones
    samp_rate: samp_rate
    theta: po.theta
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: ruta3d
  id: epy_module
  parameters:
    source_code: "# Lo que hace este programa es lo siguiente:\n# * calcula todos los valores angulares en los que un\n# receptor se debe ubicar con el fin de poder \n# medir todos los valores de campo y con todo eso\n# poder graficar el patron de radiacion en 3d\n# * A diferencia de lo que se hace en la programacion\n# tradicional, donde se dice que phi tiene unos valore\n# entre 0 y 360 grados y theta entre 0 y 180, aqui, por usar\n# programacion de tiempo real hay que imaginar que tomamos un dron\n# y le pre-programos toda la ruta que hay que seguir para \n# sea posible obtener todos los datos del patron de radiacion\n# de un arreglo\n#\n# Como se usa:\n# * supongamos que Ud desea que la ruta se haga que tenga Nang=128 puntos angulares por cada anilo\n# Entonces crea el objeto po=receiver_path(128) . Nota Nang debe ser tipo 2 a la m\n# * puede obtener los valores unicos de phi como po.phi\n# * los de theta como po.theta\n# * los valores que phi para toda la ruta como po.phi_path()\n# * los valores que theta para toda la ruta como po.theta_path()\n# * tambien se puede acceder al numero de anillos que la grafica\n# tendra en el eje z como po.Nrings\n# * igualmente, el numero de puntos de cada anillo po.Nang\n# * y el numero de puntos de toda la ruta po.L_path\n\nimport numpy as np\n\ndef zerooh(x,Sps):\n    Lx=len(x)\n    g=np.array([x[0]]*Sps)\n    for i in range(1,Lx):\n        g=np.concatenate((g,np.array([x[i]]*Sps)))\n    return g\n\nclass receiver_path(object):\n    def __init__(self, Nang):\n        self.Nang=Nang\n        self.Nrings=int(Nang/2)\n        self.pasoAngular=360/Nang\n        self.L_path=Nang*self.Nrings\n        #self.phi=np.linspace(0,360-self.pasoAngular,Nang)*np.pi/180\n        #self.theta=np.linspace(0,180-self.pasoAngular,self.Nrings)*np.pi/180\n        self.phi=np.linspace(0,360,Nang)*np.pi/180\n        self.theta=np.linspace(0,180,self.Nrings)*np.pi/180\n            \n    # calculo de los valores de phi para todo el recorrido            \n    def phi_path(self,):\n        return(np.tile(self.phi, self.Nrings))\n\n    # calculo de los valores de theta para todo el recorrido\n    def theta_path(self,):\n        return(zerooh(self.theta,self.Nang))\n\n\n"
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: out1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: out1
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0_1_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0_1_0_0_0_0, '0']
- [blocks_throttle_0_0_0, '0', virtual_sink_0, '0']
- [blocks_vector_source_x_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
